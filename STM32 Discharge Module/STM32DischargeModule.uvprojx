# Keil uVision project STM32DischargeModule.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32DischargeModule
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.81.0, File System:CORE 6.7.0, File System:Drive:Memory Card 6.7.0, Network:CORE 7.1.0, Network:Interface:ETH 7.1.0, Network:Service:Web Server 7.1.0, Network:Socket:TCP 7.1.0, USB:CORE 6.7.0, USB:Device 6.7.0, USB:Device:CDC 6.7.0, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:Ethernet MAC 2.6, CMSIS Driver:Ethernet PHY:LAN8720 6.1, CMSIS Driver:MCI 2.6, CMSIS Driver:USB Device:Full-speed 2.15, Compiler:Event Messaging 1.0.0, Compiler:I/O:File 1.1.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:ADC 1.5.0, Device:STM32Cube HAL:CRC 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DAC 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:IWDG 1.5.0, Device:STM32Cube HAL:PC Card 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:RNG 1.5.0, Device:STM32Cube HAL:RTC 1.5.0, Device:STM32Cube HAL:SPI 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:STM32Cube HAL:USART 1.5.0, Device:Startup 2.5.0
