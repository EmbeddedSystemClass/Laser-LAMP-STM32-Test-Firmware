# Keil uVision project CalipsoBootloader.uvprojx, settings and files
target Calipso-Bootloader (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CalipsoBootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Periph
    ./: GlobalVariables.c MainThread.c SDCardBase.c DGUSBase.c
  group RT
    ./: rtEventSystem.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Compiler:Event Recorder 1.1.0, Compiler:I/O:File 1.1.0, Compiler:I/O:STDERR 1.1.0, Compiler:I/O:STDIN 1.1.0, Compiler:I/O:STDOUT 1.1.0, Compiler:I/O:TTY 1.1.0, File System:CORE 6.9.0, File System:Drive:Memory Card 6.9.0, CMSIS Driver:MCI 2.6, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:Flash 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:STM32Cube HAL:USART 1.5.0, Device:Startup 2.5.0
